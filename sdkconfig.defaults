## sdkconfig.defaults
```kconfig
CONFIG_LWIP_L2_TO_L3_COPY=n
CONFIG_LWIP_IP_FORWARD=n
CONFIG_LWIP_IPV4_NAPT=n 
#CONFIG_ESP_SYSTEM_USE_EH_FRAME=y
#CONFIG_COMPILER_CXX_EXCEPTIONS=y
```
